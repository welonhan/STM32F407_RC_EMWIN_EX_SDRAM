# Keil uVision project Project.uvprojx, settings and files
target RC_V1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RC_V1
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM32F4_DISCO
  c misc: --C99
  c include: ..\..\Middlewares\Third_Party\FatFs\src;..\..\Drivers\BSP\STM32F4-Discovery;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares\Third_Party\FatFs\src\drivers;..\Inc;..\..\Drivers\BSP\others;..\..\Middlewares\STemWin\inc;..\..\Middlewares\STemWin\Config;..\..\GUIApp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\..\..\stm32_out\RC_V1.sct
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F4_DISCO
    ../../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c
  group Middlewares/FatFs/Core
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Middlewares/FatFs/Drivers
    ../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ../../Doc/: Readme.txt
  group Drivers/BSP/others
    ../../Drivers/BSP/others/: drv_adc.c drv_RF24L01.c stm32f4_discovery_lcd.c stm32f4_discovery_sd.c stm32f4_discovery_touch.c stm32f4_discovery_uart.c stm324xg_eval_sram.c
  group Middlewares/STemWin/Config
    ../../Middlewares/STemWin/OS/: GUI_X.c
    ../../Middlewares/STemWin/Config/: GUIConf.c GUIDRV_RC.c LCDConf_RC.c
  group Middlewares/STemWin/Lib
    ../../Middlewares/STemWin/Lib/: STemWin532_CM4_Keil.lib
  group GUIApp
    ../../GUIApp/: GUIApp.c
software components: CMSIS:CORE 4.3.0
